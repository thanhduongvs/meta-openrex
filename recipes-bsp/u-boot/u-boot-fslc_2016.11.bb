include u-boot-fslc.inc

#PV = "v2016.11+git${SRCPV}"
PV .= ""

SRCREV = "7fb8afbadaf127f4eb8782639e1c3f0777af5bd3"
SRCBRANCH = "morty"
